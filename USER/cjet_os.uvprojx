# Keil uVision project cjet_os.uvprojx, settings and files
target cjet_os (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UCOSII-1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\TIMER;..\HARDWARE\simulate_usart;..\HARDWARE\simulate_usart;..\HARDWARE\SD;..\HARDWARE\LCD;..\HARDWARE\GPS;..\HARDWARE\W25QXX;..\HARDWARE\FATFS\src;..\HARDWARE\FATFS\exfuns;..\HARDWARE\CAN;..\MALLOC;..\HARDWARE\SPI;..\PROTOCOL\SH_PROTOCOL;..\JIANKONG;..\HARDWARE\FLASH;..\HARDWARE\FLASH
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SD/: sdio_sdcard.c
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/FLASH/: flash.c
  group MONITOR
    ../JIANKONG/: gprs_jiankong.c
  group MALLOC
    ../MALLOC/: malloc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../HARDWARE/simulate_usart/: simulate_usart.c
    ../HARDWARE/TIMER/: timer.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_fsmc.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_spi.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_a.asm os_cpu_c.c os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group FATFS
    ../HARDWARE/FATFS/: fattester.c
    ../HARDWARE/FATFS/src/: diskio.c ff.c
    ../HARDWARE/FATFS/exfuns/: exfuns.c
